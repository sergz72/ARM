# Keil uVision project SWR_meter.uvprojx, settings and files
target STM32F030F4P6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWR_meter
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c include: D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;src;..\stm32f0lib;..\common_lib
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c
  group lib
    ../stm32f0lib/: timer.c gpio.c nvic.c adc.c i2c.c
    ../common_lib/: lcd.c lcd_ssd1306.c font.c
    ../common_lib/fonts/: font16.c font8_2.c
software components: Device:Startup 1.5.0
