# Keil uVision project drillironc.uvprojx, settings and files
target STM32F050F4 (ARM-ADS)
  device: STM32F050F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: drillironc
  c flags: Optim=3 oTime=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c drill.c heater.c
  group lib
    ../stm32lib/: adc.c gpio.c serial.c systick.c timer.c nvic.c
  group ::Device
    RTE/Device/STM32F050F4/: startup_stm32f0xx.s system_stm32f0xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
