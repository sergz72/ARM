# Keil uVision project charger_stm32f103.uvprojx, settings and files
target STM32F103R4 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103R4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: charger_stm32f103
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: src;..\stm32lib;..\common_lib;..\stm32lib\usb;..\stm32lib\usb\cdc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group src
    ./src/: startup_stm32f10x_ld.s main.c commands.c
  group lib
    ../stm32lib/: adc.c pll.c systick.c nvic.c timer.c dma.c
    ../stm32lib/usb/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../stm32lib/usb/cdc/: usb_cdc.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
software components: CMSIS:CORE 4.3.0
