# Keil uVision project lamp_heater_control.uvprojx, settings and files
target STM32F103C8 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lamp_heater_control
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: commands.c main.c startup_stm32f10x_md.s
  group lib
    ../stm32lib/: adc.c systick.c pll.c nvic.c
    ../stm32lib/usb/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../stm32lib/usb/cdc/: usb_cdc.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../common_lib/: itoa.c
